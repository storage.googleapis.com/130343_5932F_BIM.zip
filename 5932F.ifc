Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:29:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:29:25 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{EC25641F-B428-4B90-8DCA-AA63FAD07498}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:29:24 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:29:24 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:29:24 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 5932F Kitchen faucet with dishwasher valve, 5932F:5932F Kitchen faucet with dishwasher valve:317293
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 214.06 mm; NominalHeight: 312.4 mm; NominalWidth: 376.81 mm
Type - General - Author: Convergo AB; BIMObjectName: 5932F; ConvergoRefNr: 0087-1806-0047-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with swivel pull-out spout with aerator. Spout swing angle 60° (factory default) or 110°.; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2018
Type - Green Building Properties - EAN Number: 6414150047268; Noise Class: I (ISO 3822); RSK Number: 8347963; STF Certificate: STF VTT-RTH-00098-11
Type - Identity Data - Class: Single lever; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;EST;LVA;LTU;POL;SWE;RUS;UKR; Model: 5932F Kitchen faucet with dishwasher valve; Name_en: 5932F Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5932F; Product Datasheet: https://www.oras.com/datasheet/5932F/en; Product Family: Oras Aventa; Product URL: https://www.oras.com/en/products/oras-aventa/product/5932F/; Type Name: 5932F Kitchen faucet with dishwasher valve
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Aerator; Dishwasher Valve: Washing machine malve; Flow Rate At 300kPa: 0.00670979 m3/s; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pressure Loss With Flow 02ls: 330000 Pa; Spout Type: Pullout spout
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5932F; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5932F; Name: 5932F Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 377x214x312 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 5932F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5932F Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.26632 m2; Volume: 0.0251991 m3
Identity Data - Mark: 13
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5932F: 5932F Kitchen faucet with dishwasher valve; Family and Type: 5932F: 5932F Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5932F: 5932F Kitchen faucet with dishwasher valve; Type Id: 5932F: 5932F Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
